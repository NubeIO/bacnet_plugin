# IAR project bacnet.ewp, settings and files
configuration Release-644p (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x400
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m644p    ATmega644P
  ICCAVR.CCDefines: NDEBUG; BACDL_MSTP; MAX_APDU=128; MAX_TSM_TRANSACTIONS=0; MSTP_PDU_PACKET_COUNT=2; MAX_CHARACTER_STRING_BYTES=64; MAX_OCTET_STRING_BYTES=64; BACAPP_BOOLEAN; BACAPP_REAL; BACAPP_OBJECT_ID; BACAPP_UNSIGNED; BACAPP_ENUMERATED; BACAPP_CHARACTER_STRING; BACAPP_OCTET_STRING; WRITE_PROPERTY
  ICCAVR.CCDiagSuppress: Pa084
  ICCAVR.newCCIncludePaths: $PROJ_DIR$; ..\..\src
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm644p.xcl
configuration Release-1284p (AVR)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.GenDeviceSelectMenu: m1284p   ATmega1284P
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1284p.xcl
configuration Debug-644p (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: BACDL_MSTP; MAX_ANALOG_INPUTS=100; MAX_APDU=50; MAX_TSM_TRANSACTIONS=0; MSTP_PDU_PACKET_COUNT=2; MAX_CHARACTER_STRING_BYTES=64; MAX_OCTET_STRING_BYTES=64; BACAPP_BOOLEAN; BACAPP_REAL; BACAPP_OBJECT_ID; BACAPP_UNSIGNED; BACAPP_ENUMERATED; BACAPP_CHARACTER_STRING; BACAPP_OCTET_STRING; WRITE_PROPERTY
configuration Debug-1284p (AVR, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.GenDeviceSelectMenu: m1284p   ATmega1284P
  ICCAVR.CCDefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm1284p.xcl
  group (top)
    ./: adc.c ai.c av.c bacnet.c bi.c bname.c bo.c device.c dlmstp.c eeprom.c fuses.c init.c input.c led.c main.c mstimer-init.c netport.c rs485.c seeprom.c serial.c stack.c test.c watchdog.c
    ../../src/bacnet/basic/sys/: bigend.c
  group BACnet Basic
    ../../src/bacnet/basic/service/: h_apdu.c h_dcc.c h_noserv.c h_rd.c h_rp.c h_rpm.c h_whohas.c h_whois.c h_wp.c s_iam.c s_ihave.c
    ../../src/bacnet/basic/npdu/: h_npdu.c
    ../../src/bacnet/basic/tsm/: tsm.c
  group BACnet Basic Sys
    ../../src/bacnet/basic/sys/: debug.c fifo.c mstimer.c ringbuf.c
  group BACnet Datalink
    ../../src/bacnet/datalink/: crc.c
  group BACnet-Core
    ../../src/bacnet/: abort.c bacaddr.c bacapp.c bacdcode.c bacerror.c bacint.c bacreal.c bacstr.c dcc.c iam.c ihave.c memcopy.c npdu.c proplist.c rd.c reject.c rp.c rpm.c whohas.c whois.c wp.c
