# IAR project bacnet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: BACDL_MSTP; MAX_TSM_TRANSACTIONS=0; MAX_CHARACTER_STRING_BYTES=64; MAX_OCTET_STRING_BYTES=64; PRINT_ENABLED=0; MAX_APDU=480; CRC_USE_TABLE; BACAPP_MINIMAL
  ICCARM.CCDiagSuppress: Pa084,Pe186,Pe188
  ICCARM.CCIncludePath2: ..\..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bacnet.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: ai.c av.c bi.c blinker.c bv.c device.c dlmstp.c init.c isr.c main.c netport.c rs485.c timer.c
  group BACnet-Basic
    ../../src/bacnet/basic/sys/: bigend.c ringbuf.c debug.c
    ../../src/bacnet/basic/service/: h_apdu.c h_dcc.c h_noserv.c h_rd.c h_rp.c h_rpm.c h_whohas.c h_whois.c h_wp.c s_iam.c s_ihave.c
    ../../src/bacnet/basic/npdu/: h_npdu.c
    ../../src/bacnet/basic/tsm/: tsm.c
  group BACnet-Core
    ../../src/bacnet/: abort.c bacaddr.c bacapp.c bacdcode.c bacdest.c bacdevobjpropref.c bacerror.c bacint.c bacreal.c bacstr.c datetime.c dcc.c hostnport.c iam.c ihave.c lighting.c memcopy.c npdu.c proplist.c rd.c reject.c rp.c rpm.c shed_level.c timer_value.c timestamp.c whohas.c whois.c wp.c
    ../../src/bacnet/datalink/: crc.c
