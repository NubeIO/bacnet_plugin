# IAR project bacnet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZG  ST STM32F103ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_XL; USE_STDPERIPH_DRIVER; BACDL_MSTP; MAX_APDU=480; MAX_TSM_TRANSACTIONS=0; BACAPP_MINIMAL
  ICCARM.CCDiagSuppress: Pe550,Pa084
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\src; external\CMSIS\; external\drivers\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: bacnet.c bo.c device.c led.c main.c mstimer-init.c netport.c rs485.c stm32f10x_it.c system_stm32f10x.c
  group BACnet
    ../../src/bacnet/: abort.c bacaddr.c bacapp.c bacdcode.c bacdest.c bacdevobjpropref.c bacerror.c bacint.c bacreal.c bacstr.c dcc.c indtext.c iam.c ihave.c hostnport.c lighting.c memcopy.c npdu.c proplist.c proplist.c rd.c reject.c rp.c rpm.c shed_level.c timer_value.c timestamp.c whohas.c whois.c wp.c
  group BACnet-Datalink
    ../../src/bacnet/datalink/: cobs.c crc.c dlmstp.c mstp.c mstptext.c
  group BACnet-Basic-Services
    ../../src/bacnet/basic/service/: h_apdu.c h_dcc.c h_noserv.c h_rd.c h_rp.c h_rpm.c h_whohas.c h_whois.c h_wp.c s_iam.c s_ihave.c
    ../../src/bacnet/basic/npdu/: h_npdu.c
    ../../src/bacnet/basic/tsm/: tsm.c
  group BACnet-Basic-System
    ../../src/bacnet/basic/sys/: bigend.c debug.c fifo.c mstimer.c ringbuf.c
  group CMSIS
    external/CMSIS/iar/: startup_stm32f10x_xl.s
  group STM32-Lib
    external/drivers/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_misc.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
